# Keil uVision project dataflash.uvproj, settings and files
target RUN_IN_DDRAM (ARM-ADS)
  device: AT91SAM9G45 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: dataflash +hex
  AfterMake: fromelf.exe --bin -o  ../download/dataflash.bin ./RUN_IN_DDRAM/dataflash.axf
  c flags: Optim=1
  c define: at91sam9g45 NOFPUT ddram TRACE_LEVEL=4
  c misc: --gnu
  c include: ..\..\common\at91lib\memories;..\..\common\at91lib\peripherals;..\..\common\at91lib
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: ..\..\common\at91lib\boards\at91sam9g45\ddram.sct
  link misc: --entry resetHandler
  group startup
    ../../common/at91lib/peripherals/cp15/: cp15_asm_keil.s
    ../../common/at91lib/boards/: board_cstartup_keil.s
  group at91lib
    ../../common/at91lib/memories/spi-flash/: at45.c spid.c
    ../../common/at91lib/peripherals/cp15/: cp15.c
    ../../common/at91lib/utility/: trace.c retarget.c
    ../../common/at91lib/peripherals/dbgu/: dbgu.c
    ../../common/at91lib/peripherals/irq/: aic.c
    ../../common/at91lib/peripherals/pio/: pio.c
    ../../common/at91lib/peripherals/pmc/: pmc.c
    ../../common/at91lib/boards/: board_lowlevel.c board_memories.c
  group usr
    ../src/: main.c
  group Readme
    ../Readme/: Readme.txt
target RUN_IN_SRAM (ARM-ADS)
  device: AT91SAM9G45 Atmel
  cpu: as above
  output: dataflash
  c flags: Optim=1
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
