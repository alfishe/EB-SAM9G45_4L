# Keil uVision project fs.uvproj, settings and files
target RUN_IN_DDRAM (ARM-ADS)
  device: AT91SAM9G45 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: fs
  AfterMake: fromelf.exe --bin -o  ../download/fs.bin ./RUN_IN_DDRAM/fs.axf
  c flags: Optim=1
  c define: at91sam9g45 ddram NOFPUT  TRACE_LEVEL=2
  c misc: --gnu
  c include: ..\inc;..\..\common\at91lib;..\..\common\at91lib\boards;..\..\common\at91lib\boards\at91sam9g45;..\..\common\at91lib\memories;..\..\common\at91lib\peripherals;..\..\common\at91lib\drivers\fat;..\..\common\at91lib\drivers\fat\fatfs;..\..\common\at91lib\drivers\fat\fatfs\src;..\..\common\at91lib\drivers\fat\efsl;..\..\common\at91lib\drivers\fat\efsl\inc;..\..\common\at91lib\drivers\fat\efsl\src;..\..\common\at91lib\drivers\fat\efsl\conf;..\..\common\at91lib\drivers\fat\efsl\inc\interfaces;..\..\common\at91lib\drivers\fat\efsl\src\interfaces
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: ..\..\common\at91lib\boards\at91sam9g45\ddram.sct
  link misc: --entry resetHandler
  group startup
    ../../common/at91lib/boards/: board_cstartup_keil.s
  group at91lib
    ../../common/at91lib/boards/: board_lowlevel.c board_memories.c
    ../../common/at91lib/memories/: MEDDdram.c Media.c MEDSdram.c
    ../../common/at91lib/peripherals/dbgu/: dbgu.c
    ../../common/at91lib/peripherals/irq/: aic.c
    ../../common/at91lib/peripherals/pio/: pio.c pio_it.c
    ../../common/at91lib/peripherals/pit/: pit.c
    ../../common/at91lib/usb/common/core/: USBConfigurationDescriptor.c USBEndpointDescriptor.c USBFeatureRequest.c USBGenericDescriptor.c USBGenericRequest.c USBGetDescriptorRequest.c USBInterfaceRequest.c USBSetAddressRequest.c USBSetConfigurationRequest.c
    ../../common/at91lib/usb/device/core/: USBDCallbacks_Initialized.c USBDCallbacks_Reset.c USBDCallbacks_Resumed.c USBDCallbacks_Suspended.c USBDDriver.c USBDDriverCb_IfSettingChanged.c USBD_OTGHS.c USBD_UDP.c USBD_UDPHS.c
    ../../common/at91lib/usb/device/massstorage/: MSDDStateMachine.c MSDDriver.c MSDDriverDescriptors.c MSDLun.c SBCMethods.c
    ../../common/at91lib/utility/: led.c math.c trace.c retarget.c
    ../../common/at91lib/peripherals/cp15/: cp15_asm_keil.s
  group user
    ../src/: main.c
  group external_libs
    ../../common/at91lib/drivers/fat/efsl/src/: dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
    ../../common/at91lib/drivers/fat/efsl/src/interfaces/: at91sam_media.c
    ../../common/at91lib/drivers/fat/fatfs/src/: diskio.c ff.c ff_util.c tff.c
  group Readme
    ../Readme/: Readme.txt
