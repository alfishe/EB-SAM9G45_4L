# Keil uVision project eamc_uip_helloworld.uvproj, settings and files
target RUN_IN_DDRAM (ARM-ADS)
  device: AT91SAM9G45 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: eamc_uip_helloworld
  AfterMake: fromelf.exe --bin -o  ../download/eamc_uip_helloworld.bin ./RUN_IN_DDRAM/eamc_uip_helloworld.axf
  c flags: Optim=1
  c define: at91sam9g45 ddram NOFPUT  TRACE_LEVEL=4
  c misc: --gnu
  c include: ..\..\common\at91lib;..\..\common\at91lib\utility;..\..\common\at91lib\peripherals;..\..\common\at91lib\drivers;..\..\common\at91lib\boards;..\inc;..\..\common\at91lib\drivers\ethernet\uip\uip
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: ..\..\common\at91lib\boards\at91sam9g45\ddram.sct
  link misc: --entry resetHandler
  group startup
    ../../common/at91lib/boards/: board_cstartup_keil.s
    ../../common/at91lib/peripherals/cp15/: cp15_asm_keil.s
  group at91lib
    ../../common/at91lib/boards/: board_memories.c board_lowlevel.c
    ../../common/at91lib/peripherals/cp15/: cp15.c
    ../../common/at91lib/peripherals/emac/: emac.c
    ../../common/at91lib/drivers/macb/: macb.c
    ../../common/at91lib/peripherals/dbgu/: dbgu.c
    ../../common/at91lib/peripherals/irq/: aic.c
    ../../common/at91lib/peripherals/pio/: pio.c
    ../../common/at91lib/peripherals/pmc/: pmc.c
    ../../common/at91lib/peripherals/rstc/: rstc.c
    ../../common/at91lib/peripherals/tc/: tc.c
    ../../common/at91lib/peripherals/usart/: usart.c
    ../../common/at91lib/utility/: trace.c retarget.c
  group eamc_lib
    ../../common/at91lib/drivers/ethernet/uip/apps/dhcpc/: dhcpc.c
    ../../common/at91lib/drivers/ethernet/uip/apps/hello-world/: hello-world.c
    ../../common/at91lib/drivers/ethernet/uip/lib/: memb.c
    ../../common/at91lib/drivers/ethernet/uip/uip/: timer.c psock.c uip.c uip_arp.c
  group usr
    ../src/: tapdev.c main.c clock-arch.c
  group Readme
    ../Readme/: Readme.txt
target RUN_IN_SRAM (ARM-ADS)
  device: AT91SAM9G45 Atmel
  cpu: as above
  output: eamc_uip_helloworld
  c flags: Optim=1
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
