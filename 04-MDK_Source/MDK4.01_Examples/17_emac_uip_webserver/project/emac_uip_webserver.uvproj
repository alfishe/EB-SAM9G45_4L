# Keil uVision project emac_uip_webserver.uvproj, settings and files
target emac_uip_webserver (ARM-ADS)
  device: AT91SAM9G45 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: emac_uip_webserver
  AfterMake: fromelf.exe --bin -o  ../download/emac_uip_webserver.bin ./RUN_IN_DDRAM/emac_uip_webserver.axf
  c flags: Optim=1
  c define: at91sam9g45 ddram NOFPUT  TRACE_LEVEL=4
  c misc: --gnu
  c include: ..\..\common\at91lib;..\..\common\at91lib\boards;..\..\common\at91lib\peripherals;..\inc;..\..\common\at91lib\drivers\ethernet\uip\uip;..\..\common\at91lib\drivers\ethernet\uip\apps\dhcpc;..\..\common\at91lib\drivers\ethernet\uip\apps\webserver;..\..\common\at91lib\drivers
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: ..\..\common\at91lib\boards\at91sam9g45\ddram.sct
  link misc: --entry resetHandler
  group startup
    ../../common/at91lib/boards/: board_cstartup_keil.s
  group at91lib
    ../../common/at91lib/boards/: board_lowlevel.c board_memories.c
    ../../common/at91lib/drivers/macb/: macb.c
    ../../common/at91lib/peripherals/cp15/: cp15.c cp15_asm_keil.s
    ../../common/at91lib/peripherals/dbgu/: dbgu.c
    ../../common/at91lib/peripherals/emac/: emac.c
    ../../common/at91lib/peripherals/irq/: aic.c
    ../../common/at91lib/peripherals/pio/: pio.c
    ../../common/at91lib/peripherals/pmc/: pmc.c
    ../../common/at91lib/peripherals/rstc/: rstc.c
    ../../common/at91lib/peripherals/tc/: tc.c
    ../../common/at91lib/peripherals/usart/: usart.c
    ../../common/at91lib/utility/: trace.c retarget.c
    ../../common/at91lib/drivers/ethernet/uip/apps/dhcpc/: dhcpc.c
    ../../common/at91lib/drivers/ethernet/uip/apps/webserver/: http-strings.c httpd-cgi.c httpd-fs.c httpd-fsdata.c httpd.c
    ../../common/at91lib/drivers/ethernet/uip/lib/: memb.c
    ../../common/at91lib/drivers/ethernet/uip/uip/: psock.c timer.c uip.c uip_arp.c
  group user
    ../src/: clock-arch.c main.c tapdev.c
  group Readme
    ../Readme/: Readme.txt
