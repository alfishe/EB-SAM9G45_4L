# Keil uVision project buzzer.uvproj, settings and files
target Buzzer (ARM-ADS)
  device: AT91SAM9G45 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: buzzer
  AfterMake: fromelf.exe --bin -o  ../download/buzzer.bin ./RUN_IN_DDRAM/buzzer.axf
  c flags: Optim=1
  c define: at91sam9g45 ddram NOFPUT  TRACE_LEVEL=4
  c misc: --gnu
  c include: ..\inc;..\..\common\at91lib;..\..\common\at91lib\boards;..\..\common\at91lib\drivers;..\..\common\at91lib\peripherals;..\..\common\at91lib\utility
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: ..\..\common\at91lib\boards\at91sam9g45\ddram.sct
  group startup
    ../../common/at91lib/boards/: board_cstartup_keil.s
  group at91lib
    ../../common/at91lib/boards/: board_lowlevel.c board_memories.c
    ../../common/at91lib/peripherals/cp15/: cp15.c cp15_asm_keil.s
    ../../common/at91lib/peripherals/dbgu/: dbgu.c
    ../../common/at91lib/utility/: retarget.c trace.c math.c
    ../../common/at91lib/peripherals/pmc/: pmc.c
    ../../common/at91lib/peripherals/pio/: pio.c
    ../../common/at91lib/peripherals/irq/: aic.c
  group user
    ../src/: main.c
  group readme
    ../Readme/: Readme.txt
