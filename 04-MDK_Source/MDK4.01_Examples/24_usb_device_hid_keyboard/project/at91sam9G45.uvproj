# Keil uVision project at91sam9G45.uvproj, settings and files
target RUN_IN_DDRAM (ARM-ADS)
  device: AT91SAM9G45 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: at91sam9G45
  AfterMake: fromelf.exe --bin -o  ../download/at91sam9G45.bin ./RUN_IN_DDRAM/at91sam9G45.axf
  c flags: Optim=1
  c define: at91sam9g45 ddram NOFPUT  TRACE_LEVEL=4
  c misc: --gnu
  c include: ..\..\common\at91lib\utility;..\..\common\at91lib\peripherals;..\..\common\at91lib\boards;..\..\common\at91lib
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: ..\..\common\at91lib\boards\at91sam9g45\ddram.sct
  link misc: --entry resetHandler
  group startup
    ../../common/at91lib/boards/: board_cstartup_keil.s
    ../../common/at91lib/peripherals/cp15/: cp15_asm_keil.s
  group at91lib
    ../../common/at91lib/peripherals/cp15/: cp15.c
    ../../common/at91lib/peripherals/irq/: aic.c
    ../../common/at91lib/peripherals/pio/: pio.c pio_it.c
    ../../common/at91lib/peripherals/pmc/: pmc.c
    ../../common/at91lib/peripherals/dbgu/: dbgu.c
    ../../common/at91lib/utility/: retarget.c trace.c led.c
    ../../common/at91lib/boards/: board_memories.c board_lowlevel.c
    ../../common/at91lib/peripherals/pit/: pit.c
    ../../common/at91lib/usb/common/core/: USBSetConfigurationRequest.c USBConfigurationDescriptor.c USBEndpointDescriptor.c USBFeatureRequest.c USBGenericDescriptor.c USBGenericRequest.c USBGetDescriptorRequest.c USBInterfaceRequest.c USBSetAddressRequest.c
    ../../common/at91lib/usb/common/hid/: HIDReportRequest.c HIDIdleRequest.c HIDKeypad.c
    ../../common/at91lib/usb/device/core/: USBD_OTGHS.c USBD_UDP.c USBD_UDPHS.c USBDCallbacks_Initialized.c USBDCallbacks_Reset.c USBDDriver.c USBDDriverCb_IfSettingChanged.c
    ../../common/at91lib/usb/device/hid-keyboard/: HIDDKeyboardOutputReport.c HIDDKeyboardDriver.c HIDDKeyboardDriverDescriptors.c HIDDKeyboardInputReport.c
  group usr
    ../src/: main.c
  group Readme
    ../Readme/: Readme.txt
target RUN_IN_SRAM (ARM-ADS)
  device: AT91SAM9G45 Atmel
  cpu: as above
  output: at91sam9G45
  c flags: Optim=1
  c define: at91sam9g45 ddram NOFPUT  TRACE_LEVEL=4
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: ..\..\common\at91lib\boards\at91sam9g45\sram.sct
