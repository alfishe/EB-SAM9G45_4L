# Keil uVision project usb_device_cdc_serial.uvproj, settings and files
target usb_device_cdc_serial (ARM-ADS)
  device: AT91SAM9G45 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: usb_device_cdc_serial
  AfterMake: fromelf.exe --bin -o  ../download/usb_device_cdc_serial.bin ./RUN_IN_DDRAM/usb_device_cdc_serial.axf
  c flags: Optim=1
  c define: at91sam9g45 ddram NOFPUT  TRACE_LEVEL=3
  c misc: --gnu
  c include: ..\..\common\at91lib;..\..\common\at91lib\boards;..\..\common\at91lib\peripherals;..\inc
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: ..\..\common\at91lib\boards\at91sam9g45\ddram.sct
  link misc: --entry resetHandler
  group startup
    ../../common/at91lib/boards/: board_cstartup_keil.s
  group at91lib
    ../../common/at91lib/boards/: board_lowlevel.c board_memories.c
    ../../common/at91lib/peripherals/cp15/: cp15.c cp15_asm_keil.s
    ../../common/at91lib/peripherals/dbgu/: dbgu.c
    ../../common/at91lib/peripherals/irq/: aic.c
    ../../common/at91lib/peripherals/pio/: pio.c pio_it.c
    ../../common/at91lib/peripherals/pmc/: pmc.c
    ../../common/at91lib/peripherals/usart/: usart.c
    ../../common/at91lib/usb/common/cdc/: CDCLineCoding.c CDCSetControlLineStateRequest.c
    ../../common/at91lib/usb/common/core/: USBConfigurationDescriptor.c USBEndpointDescriptor.c USBFeatureRequest.c USBGenericDescriptor.c USBGenericRequest.c USBGetDescriptorRequest.c USBInterfaceRequest.c USBSetAddressRequest.c USBSetConfigurationRequest.c
    ../../common/at91lib/usb/device/cdc-serial/: CDCDSerialDriver.c CDCDSerialDriverDescriptors.c
    ../../common/at91lib/usb/device/core/: USBDCallbacks_Initialized.c USBDCallbacks_Reset.c USBDDriver.c USBDDriverCb_CfgChanged.c USBDDriverCb_IfSettingChanged.c USBD_OTGHS.c USBD_UDP.c USBD_UDPHS.c
    ../../common/at91lib/utility/: led.c trace.c retarget.c
  group user
    ../src/: main.c
  group Readme
    ../Readme/: Readme.txt
