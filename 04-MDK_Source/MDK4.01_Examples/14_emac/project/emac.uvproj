# Keil uVision project emac.uvproj, settings and files
target RUN_IN_DDRAM (ARM-ADS)
  device: AT91SAM9G45 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: emac
  AfterMake: fromelf.exe --bin -o  ../download/emac.bin ./RUN_IN_DDRAM/emac.axf
  c flags: Optim=1
  c define: at91sam9g45 ddram NOFPUT  TRACE_LEVEL=4
  c misc: --gnu
  c include: ..\inc;..\..\common\at91lib;..\..\common\at91lib\boards;..\..\common\at91lib\boards\at91sam9g45;..\..\common\at91lib\peripherals
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: ..\..\common\at91lib\boards\at91sam9g45\ddram.sct
  link misc: --entry resetHandler
  group startup
    ../../common/at91lib/boards/: board_cstartup_keil.s
  group at91lib
    ../../common/at91lib/boards/: board_lowlevel.c board_memories.c
    ../../common/at91lib/drivers/macb/: macb.c
    ../../common/at91lib/peripherals/cp15/: cp15.c cp15_asm_keil.s
    ../../common/at91lib/peripherals/dbgu/: dbgu.c
    ../../common/at91lib/peripherals/emac/: emac.c
    ../../common/at91lib/peripherals/irq/: aic.c
    ../../common/at91lib/peripherals/pio/: pio.c
    ../../common/at91lib/peripherals/pmc/: pmc.c
    ../../common/at91lib/peripherals/rstc/: rstc.c
    ../../common/at91lib/peripherals/usart/: usart.c
    ../../common/at91lib/utility/: trace.c retarget.c
  group user
    ../src/: MiniIp.c main.c
  group Readme
    ../Readme/: Readme.txt
target RUN_IN_SRAM (ARM-ADS)
  device: AT91SAM9G45 Atmel
  cpu: as above
  output: emac
  c flags: Optim=1
  c define: at91sam9g45 sram NOFPUT  TRACE_LEVEL=4
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: ..\..\common\at91lib\boards\at91sam9g45\sram.sct
  link misc: --entry resetHandler
