# Keil uVision project nandflash.uvproj, settings and files
target nandflash (ARM-ADS)
  device: AT91SAM9G45 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: nandflash
  AfterMake: fromelf.exe --bin -o  ../download/nandflash.bin ./RUN_IN_DDRAM/nandflash.axf
  c flags: Optim=1
  c define: at91sam9g45 ddram NOFPUT  TRACE_LEVEL=4
  c misc: --gnu
  c include: ..\..\common\at91lib;..\..\common\at91lib\boards;..\..\common\at91lib\peripherals;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: ..\..\common\at91lib\boards\at91sam9g45\ddram.sct
  link misc: --entry resetHandler
  group startup
    ../../common/at91lib/boards/: board_cstartup_keil.s
  group at91lib
    ../../common/at91lib/boards/: board_lowlevel.c board_memories.c
    ../../common/at91lib/memories/nandflash/: EccNandFlash.c NandFlashModel.c NandFlashModelList.c NandSpareScheme.c RawNandFlash.c SkipBlockNandFlash.c
    ../../common/at91lib/peripherals/cp15/: cp15.c cp15_asm_keil.s
    ../../common/at91lib/peripherals/dbgu/: dbgu.c
    ../../common/at91lib/peripherals/pio/: pio.c
    ../../common/at91lib/peripherals/pmc/: pmc.c
    ../../common/at91lib/utility/: hamming.c math.c trace.c retarget.c
  group user
    ../src/: main.c
  group Readme
    ../Readme/: Readme.txt
